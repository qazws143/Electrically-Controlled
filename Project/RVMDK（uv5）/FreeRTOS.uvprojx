# Keil uVision project FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F1
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\HardWare\led;..\..\HardWare\Key;..\..\sys;..\..\HardWare\ST7735;..\..\RtosTask;..\..\HardWare\HCSR24;..\..\HardWare\mpu6050;..\..\HardWare\Hall;..\..\HardWare\IAP;..\..\HardWare\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group DOC
    ../../Doc/: readme.txt
  group HardWare
    ../../HardWare/led/: bsp_led.c bsp_led.h
    ../../HardWare/ST7735/: GUI.c ST7735_Driver.c font.h GUI.h ST7735_Driver.h
    ../../HardWare/mpu6050/: mpu6050.c IMU.c Kalman.c
    ../../HardWare/HCSR24/: HCSR04.c
    ../../HardWare/Hall/: Hall.c
    ../../HardWare/Key/: bsp_key.c
    ../../HardWare/FLASH/: Flash.c
    ../../HardWare/IAP/: IAP.c
  group sys
    ../../sys/: bsp_exti.c bsp_exti.h bsp_usart.c bsp_usart.h delay.c I2C.c spi.c sys.c tim.c DMA.c
  group Rtos
    ../../RtosTask/: App_Task.c
